# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h Nixie_plus.c Nixie_plus.h Timer0.c Timer0.h key_selfPlus.c key_selfPlus.h DS18B20.c DS18B20.h OneWire.c OneWire.h
