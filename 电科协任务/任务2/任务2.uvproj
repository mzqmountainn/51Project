# Keil uVision project 任务2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 任务2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h key.c key.h LCD1602.c LCD1602.h Timer0.c Timer0.h key_plus.c key_plus.h Timer1.c Timer1.h
