# Keil uVision project 任务3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 任务3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h UART.c UART.h LCD1602.c LCD1602.h key_selfPlus.c key_selfPlus.h Timer0.c Timer0.h MatrixKey.c MatrixKey.h AT24C02.c AT24C02.h I2C.c I2C.h
